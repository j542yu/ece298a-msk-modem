v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {buffer.sym} 220 -190 0 0 {name=x1}
C {vsource.sym} 90 -70 0 0 {name=V1 value=3 savecurrent=false}
C {vsource.sym} 170 -70 0 0 {name=V2 value=3 savecurrent=false}
C {gnd.sym} 370 -180 0 0 {name=l1 lab=GND}
C {gnd.sym} 90 -40 0 0 {name=l2 lab=GND}
C {gnd.sym} 170 -40 0 0 {name=l3 lab=GND}
